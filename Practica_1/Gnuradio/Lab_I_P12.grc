options:
  parameters:
    generate_options: qt_gui
    id: Lab_I_P12
    output_language: python
    title: Punto_12
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\yuri9\OneDrive\Documentos\Brayan\Lab_com_II\police-radio-chatter-.wav
    repeat: 'False'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \n    def __init__(self):\n        # solo argumentos por defecto aquí\n        gr.sync_block.__init__(\n            self,\n            name='Acomulador',  # nombre que aparecerá en GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n\n    def work(self, input_items, output_items):\n        x = input_items[0]  # Señal de entrada\n        y0 = output_items[0]  # Señal acumulada\n        y0[:] = np.cumsum(x)  # Acumula la señal de entrada\n        \n        return len(y0)  # Devolver la longitud de la señal de salida\n\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              # Solo argumentos por defecto aquí
              gr.sync_block.__init__(
                  self,
                  name='Diferenciador',  # Nombre que aparecerá en GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              
              # Atributo inicializado fuera de la llamada a __init__
              self.acum_anterior = 0

          def work(self, input_items, output_items):
              x = input_items[0]  # Señal de entrada
              y0 = output_items[0]  # Señal acumulada diferencial

              N = len(x)

              # Cálculo de la diferencia acumulada
              diff = np.cumsum(x) - self.acum_anterior
              self.acum_anterior = np.cumsum(x)[-1]  # Guardar el último valor acumulado

              # Asignar el resultado a la salida
              y0[:] = diff

              return len(x)  # Retorna la longitud de la señal de entrada procesada
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          
          def __init__(self):
              # Solo argumentos por defecto aquí
              gr.sync_block.__init__(
                  self,
                  name='Promedios_de_tiempos',  # Nombre que aparecerá en GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32, np.float32, np.float32, np.float32, np.float32]
              )
              
              self.acum_anterior = 0
              self.Ntotales = 0
              self.acum_anterior1 = 0
              self.acum_anterior2 = 0

          def work(self, input_items, output_items):
              x = input_items[0]  # Señal de entrada
              y0 = output_items[0]  # Promedio de la señal
              y1 = output_items[1]  # Media de la señal
              y2 = output_items[2]  # RMS de la señal
              y3 = output_items[3]  # Potencia promedio de la señal
              y4 = output_items[4]  # Desviación estándar de la señal

              # Cálculo del promedio
              N = len(x)
              self.Ntotales += N
              acumulado = self.acum_anterior + np.cumsum(x)
              self.acum_anterior = acumulado[-1]
              y0[:] = acumulado / self.Ntotales

              # Cálculo de la media cuadrática
              x2 = np.multiply(x, x)
              acumulado1 = self.acum_anterior1 + np.cumsum(x2)
              self.acum_anterior1 = acumulado1[-1]
              y1[:] = acumulado1 / self.Ntotales

              # Cálculo del RMS
              y2[:] = np.sqrt(y1)

              # Cálculo de la potencia promedio
              y3[:] = np.multiply(y2, y2)

              # Cálculo de la desviación estándar
              x3 = np.multiply(x - y0, x - y0)
              acumulado2 = self.acum_anterior2 + np.cumsum(x3)
              self.acum_anterior2 = acumulado2[-1]
              y4[:] = np.sqrt(acumulado2 / self.Ntotales)

              return len(x)
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media"'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media Cuadratica"'
    type: float
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"RMS"'
    type: float
  states: {}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Potencia promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_5
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Desviacion Estandar"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Diferenciador"'
    size: '10024'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Acomulador"'
    size: '10024'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Señal original"'
    size: '10024'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}

connections:
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', epy_block_1_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0, '0']
- [epy_block_1_0, '0', qtgui_number_sink_1, '0']
- [epy_block_1_0, '1', qtgui_number_sink_2, '0']
- [epy_block_1_0, '2', qtgui_number_sink_3, '0']
- [epy_block_1_0, '3', qtgui_number_sink_4, '0']
- [epy_block_1_0, '4', qtgui_number_sink_5, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
