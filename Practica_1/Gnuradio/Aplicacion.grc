options:
  parameters:
    generate_options: qt_gui
    id: Aplicacion
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\scsan\Documents\UIS\2024-2\Comunicaciones 2\Fase1\korsakov_bumblebee.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='e_Diff',  # Nombre del bloque en GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.prev_value = 0.0  # Almacena el valor anterior

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              N = len(x)

              # Concatenar el valor anterior con la señal actual
              concatenated = np.concatenate(([self.prev_value], x))
              # Calcular la diferencia
              diff = np.diff(concatenated)
              # Asignar al buffer de salida
              y[:] = diff
              # Actualizar el valor anterior
              self.prev_value = x[-1]

              return N
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, window_size=5):  # Tamaño de la ventana ajustable
              gr.sync_block.__init__(
                  self,
                  name="e_MovingAverage",  # Nombre del bloque
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.window_size = window_size
              self.buffer = np.zeros(self.window_size)  # Buffer circular
              self.index = 0
              self.sum = 0.0

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              N = len(x)

              for i in range(N):
                  # Actualizar la suma eliminando el valor más antiguo y añadiendo el nuevo
                  self.sum -= self.buffer[self.index]
                  self.sum += x[i]
                  # Actualizar el buffer
                  self.buffer[self.index] = x[i]
                  # Calcular el promedio
                  y[i] = self.sum / self.window_size
                  # Mover el índice circularmente
                  self.index = (self.index + 1) % self.window_size

              return N
    window_size: '10'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          
          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name="e_Acum",  # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.accumulated_value = 0.0  # Inicializamos la acumulación en 0

          def work(self, input_items, output_items):
              x = input_items[0]  # Señal de entrada.
              y0 = output_items[0]  # Señal acumulada
              
              # Acumular la señal y mantener el estado entre llamadas
              y0[:] = np.cumsum(x) + self.accumulated_value
              self.accumulated_value = y0[-1]  # Actualizar la acumulación para la próxima llamada
              
              return len(x)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_2, '0', audio_sink_0_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
